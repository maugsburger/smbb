File: SO28.brd (EAGLE design)
At the start: 61 parts

Commit message: adjusted trace widths
Other:
- board outline added: 38.1 x 20.3 mm
- board text added: "SO28"
